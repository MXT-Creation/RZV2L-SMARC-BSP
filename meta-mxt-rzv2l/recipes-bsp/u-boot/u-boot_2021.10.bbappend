FILESEXTRAPATHS_prepend := "${THISDIR}/2021.10:"

SRC_URI_append = "\
 	file://1000-MXT_SMARC-sd1-pwr-en-pin-adaption_rzv2l.patch \
"

