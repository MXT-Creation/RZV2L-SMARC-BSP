require include/core-image-sdk.inc
require include/extend_packages.inc

TOOLCHAIN_TARGET_TASK_append = " drpai "
